<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>tnc_nx_nx_encoder</key>
<param><key>id</key><value>tnc_nx_nx_encoder_0</value></param>
</block>
<block>
<key>tnc_nx_tnc</key>
<param><key>id</key><value>tnc_nx_tnc_0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>tnc_nx_nx_decoder</key>
<param><key>id</key><value>tnc_nx_nx_decoder_1_0</value></param>
</block>
<block>
<key>tnc_nx_nx_decoder</key>
<param><key>id</key><value>tnc_nx_nx_decoder_1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>port</key><value>9000</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>split_modulator</key>
<param><key>id</key><value>split_modulator_0</value></param>
<param><key>gain</key><value>tx_gain</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
<param><key>freq</key><value>3000</value></param>
<param><key>amp</key><value>ptt_amp</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX Bit Inversion</value></param>
<param><key>value</key><value>-0.3</value></param>
<param><key>min</key><value>-1</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX Bit Inversion</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>-1</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>2</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>signal_demodulator</key>
<param><key>id</key><value>signal_demodulator_0</value></param>
<param><key>dc_block_len</key><value>1000</value></param>
<param><key>samp_per_sym</key><value>10</value></param>
<param><key>rx_bit_inv</key><value>rx_gain</value></param>
</block>
<block>
<key>signal_demodulator</key>
<param><key>id</key><value>signal_demodulator_0_0</value></param>
<param><key>dc_block_len</key><value>1000</value></param>
<param><key>samp_per_sym</key><value>5</value></param>
<param><key>rx_bit_inv</key><value>rx_gain</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ptt_amp</value></param>
<param><key>label</key><value>PTT-Amplitude</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>gui</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['TX', 'RX', 'Waterfall']</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>TX</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.1</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.01</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>win_size</key><value>600,100</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>gui, 0</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>RX</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0.3</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.01</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>600,100</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>gui,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>600,100</value></param>
<param><key>notebook</key><value>gui,2</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>tnc_nx_nx_encoder_0</source_block_id><sink_block_id>split_modulator_0</sink_block_id><source_key>single</source_key><sink_key>4k8</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>split_modulator_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>tnc_nx_nx_encoder_0</source_block_id><sink_block_id>split_modulator_0</sink_block_id><source_key>double</source_key><sink_key>9k6</sink_key></connection>
<connection><source_block_id>tnc_nx_tnc_0</source_block_id><sink_block_id>tnc_nx_nx_encoder_0</sink_block_id><source_key>TX</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>tnc_nx_tnc_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>Output</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>tnc_nx_tnc_0</sink_block_id><source_key>pdus</source_key><sink_key>Input</sink_key></connection>
<connection><source_block_id>tnc_nx_nx_decoder_1_0</source_block_id><sink_block_id>tnc_nx_tnc_0</sink_block_id><source_key>out</source_key><sink_key>RX</sink_key></connection>
<connection><source_block_id>tnc_nx_nx_decoder_1</source_block_id><sink_block_id>tnc_nx_tnc_0</sink_block_id><source_key>out</source_key><sink_key>RX</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>signal_demodulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>signal_demodulator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tnc_nx_tnc_0</source_block_id><sink_block_id>tnc_nx_nx_decoder_1_0</sink_block_id><source_key>to_RX</source_key><sink_key>CMD</sink_key></connection>
<connection><source_block_id>tnc_nx_tnc_0</source_block_id><sink_block_id>tnc_nx_nx_decoder_1</sink_block_id><source_key>to_RX</source_key><sink_key>CMD</sink_key></connection>
<connection><source_block_id>signal_demodulator_0</source_block_id><sink_block_id>tnc_nx_nx_decoder_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>signal_demodulator_0_0</source_block_id><sink_block_id>tnc_nx_nx_decoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>split_modulator_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
